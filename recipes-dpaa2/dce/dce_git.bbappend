COMPATIBLE_MACHINE_nxp-lx2xxx = "nxp-lx2xxx"
COMPATIBLE_HOST_nxp-lx2xxx = "(aarch64).*-linux"
