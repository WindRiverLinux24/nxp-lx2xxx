COMPATIBLE_MACHINE_nxp-lx2xxx = "nxp-lx2xxx"
