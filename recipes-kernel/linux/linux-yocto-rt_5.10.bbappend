KBRANCH_nxp-lx2xxx  = "v5.10/standard/preempt-rt/nxp-sdk-5.10/nxp-soc"

require linux-yocto-nxp-lx2xxx.inc

LINUX_VERSION_nxp-lx2xxx ?= "5.10.x"
