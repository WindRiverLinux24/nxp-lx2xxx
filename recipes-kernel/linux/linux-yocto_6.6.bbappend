KBRANCH:nxp-lx2xxx  = "v6.6/standard/nxp-sdk-6.6/nxp-soc"

require linux-yocto-nxp-lx2xxx.inc
