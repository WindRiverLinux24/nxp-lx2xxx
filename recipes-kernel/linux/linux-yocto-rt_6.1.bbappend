KBRANCH:nxp-lx2xxx  = "v6.1/standard/preempt-rt/nxp-sdk-6.1/nxp-soc"

require linux-yocto-nxp-lx2xxx.inc
