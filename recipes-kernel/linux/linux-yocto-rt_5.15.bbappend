KBRANCH:nxp-lx2xxx  = "v5.15/standard/preempt-rt/nxp-sdk-5.15/nxp-soc"

require linux-yocto-nxp-lx2xxx.inc
