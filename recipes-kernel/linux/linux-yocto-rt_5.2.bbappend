require linux-yocto-nxp-lx2xxx.inc

KBRANCH_nxp-lx2xxx  = "v5.2/standard/preempt-rt/nxp-lsdk-20.04/nxp-lx2xxx"
