KBRANCH:nxp-lx2xxx  = "v6.6/standard/preempt-rt/nxp-sdk-6.6/nxp-soc"

require linux-yocto-nxp-lx2xxx.inc
