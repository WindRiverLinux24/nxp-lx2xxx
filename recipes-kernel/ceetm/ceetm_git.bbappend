COMPATIBLE_MACHINE_nxp-lx2xxx = "nxp-lx2xxx"
PACKAGE_ARCH_nxp-lx2xxx = "${MACHINE_ARCH}"
