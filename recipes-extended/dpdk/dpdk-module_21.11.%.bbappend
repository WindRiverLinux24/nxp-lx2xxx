COMPATIBLE_MACHINE:nxp-lx2xxx = "nxp-lx2xxx"
